## zephyr/Kconfig
```kconfig
config MACHO_MAP
	bool
	help
	  Set by cmake when CONFIG_NATIVE_POSIX is set and the host platform
	  is macOS.
```
